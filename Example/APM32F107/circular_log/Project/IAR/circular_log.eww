<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\circular_log.ewp</path>
    </project>
    <batchBuild />
</workspace>
