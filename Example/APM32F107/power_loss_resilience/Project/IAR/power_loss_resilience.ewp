# IAR project power_loss_resilience.ewp, settings and files
configuration APM32F107 (ARM, debug)
  General.OGChipSelectEditMenu: APM32F107VC Geehy APM32F107VC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: APM32F107xC; APM32F107_MINI
  ICCARM.CCIncludePath2: ..\..\Include; ..\..\..\..\..\Boards; ..\..\..\..\..\Libraries\APM32F10x_StdPeriphDriver\inc; ..\..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\..\Libraries\Device\Geehy\APM32F10x\Include; ..\..\..\..\..\Littlefs; ..\..\..\..\..\Littlefs\port; ..\..\..\..\..\Boards\Board_APM32F107_MINI\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: power_loss_resilience.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: power_loss_resilience.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../Source/: apm32f10x_int.c main.c
  group Board
    ../../../../../Boards/: Board.c
    ../../../../../Boards/Board_APM32F107_MINI/src/: board_delay.c
  group CMSIS
    ./: startup_apm32f107xc.s
    ../../../../../Libraries/Device/Geehy/APM32F10x/Source/: system_apm32f10x.c
  group Littlefs
    ../../../../../Littlefs/: lfs.c lfs_util.c
  group Littlefs/port
    ../../../../../Littlefs/port/: lfs_app.c lfs_flash_int_port.c lfs_spi_flash_port.c w25qxx_flash_drv.c
  group StdPeriphDriver
    ../../../../../Libraries/APM32F10x_StdPeriphDriver/src/: apm32f10x_adc.c apm32f10x_bakpr.c apm32f10x_can.c apm32f10x_crc.c apm32f10x_dac.c apm32f10x_dbgmcu.c apm32f10x_dma.c apm32f10x_dmc.c apm32f10x_eint.c apm32f10x_eth.c apm32f10x_fmc.c apm32f10x_gpio.c apm32f10x_i2c.c apm32f10x_iwdt.c apm32f10x_misc.c apm32f10x_pmu.c apm32f10x_qspi.c apm32f10x_rcm.c apm32f10x_rtc.c apm32f10x_sci2c.c apm32f10x_sdio.c apm32f10x_smc.c apm32f10x_spi.c apm32f10x_tmr.c apm32f10x_usart.c apm32f10x_wwdt.c
